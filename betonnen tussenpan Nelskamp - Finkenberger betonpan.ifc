Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: test.ifc
Time: 2011-01-01T11:11:11
Author: Architect
Organization: Building Designer Office
Written by: IFC Engine DLL version 1.03 special version
Made in: example
Authorization: The authorising person

# IfcProject, Default Project
Description: Description of Default Project

# IfcSite, Default Site
Description: Description of Default Site; RefLatitude: 24, 28, 0; RefLongitude: 54, 25, 0; RefElevation: 10 mm

# IfcBuilding, Default Building
Description: Description of Default Building

# IfcBuildingStorey, Default Building Storey
In: Default Building
Description: Description of Default Building Storey; Elevation: 0 mm

# IfcBuildingElementProxy: IFCBUILDINGELEMENTPROXY, betonnen tussenpan Nelskamp - Finkenberger betonpan
In: Default Building Storey
Description: Materiaal; Material: Default Material
BCB_Set_ifcbuildingelementproxy - WUID: AgAAAHvfZgABAAAAfT0AAAUSagAAhlIAAPtTAAAstAAAobkAAAAA; Hyperlink: http://bibliotheek.bouwconnect.nl/index.html?WUID=AgAAAHvfZgABAAAAfT0AAAUSagAAhlIAAPtTAAAstAAAobkAAAAA; breedte: 340 mm; dikte: 11.5 mm; gewapend: no; golfhoogte: 25 mm; hoogte: 36.5 mm; lengte: 420 mm; merk: Nelskamp; NL-SfB tabel 3: f2; prefab: yes; serie: Finkenberger betonpan; werkende breedte: 300 mm; gewicht per st: 4.6 kg/st; KOMO attest: yes; KOMO productcertificaat: yes; vorstbestendig: yes; soortelijke warmte: 840 j/kg·k; warmtegeleidingscoëfficiënt droog: 2 w/(m·k); eenheid: st; uurloon: 38 euro
